# Keil uVision project Vector_Mini_ST_Loader.uvprojx, settings and files
target Vector_Mini_ST_Loader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000020-0x20007FFF) IROM(0x8000000-0x8002FFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Vector_Mini_ST_Loader +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c misc: --diag_suppress=1
  c include: ..\..\firmware\platform\stm32g4\cubemx\Core\Inc;..\..\firmware\platform\stm32g4\cubemx\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\firmware\platform\stm32g4\cubemx\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\..\firmware\platform\stm32g4\cubemx\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\firmware\platform\stm32g4\cubemx\Drivers\CMSIS\Include;..\..\firmware\app;..\..\firmware\common;..\..\firmware\communication\can;..\..\firmware\communication\protocol;..\..\firmware\motor;..\..\firmware\motor\foc;..\..\firmware\motor\identification;..\..\firmware\motor\position;..\..\firmware\motor\protection;..\..\firmware\motor\trajectory;..\..\firmware\platform\api;..\..\firmware\platform\stm32g4\bsp;..\..\firmware\services\parameters;..\..\firmware\services\telemetry;..\..\firmware\third_party\segger_rtt;..\..\tests\hil\firmware;../firmware;../../shared
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: Vector_Mini_ST_Loader\Vector_Mini_ST_Loader.sct
  group Loader
    ../firmware/: loader_main.c loader_can.c loader_port.c loader_core.c loader_proto.c
    ../../shared/: boot_contract.c
  group Startup
    ../../firmware/platform/stm32g4/cubemx/MDK-ARM/: startup_stm32g431xx.s
  group Core
    ../../firmware/platform/stm32g4/cubemx/Core/Src/: system_stm32g4xx.c
  group HAL
    ../../firmware/platform/stm32g4/cubemx/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c
