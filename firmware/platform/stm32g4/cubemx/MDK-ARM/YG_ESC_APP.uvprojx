# Keil uVision project YG_ESC_APP.uvprojx, settings and files
target YG_ESC_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801BFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: YG_ESC_APP +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,CURRENT_SENSE_SHUNT_MILLIOHM=6U
  c misc: --diag_suppress=1
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../../app;../../../../common;../../../../communication/can;../../../../communication/protocol;../../../../../shared/protocol;../../../../../shared/boot;../../../../../shared/image;../../../../../shared/targets;../../../../motor;../../../../motor/foc;../../../../motor/identification;../../../../motor/position;../../../../motor/protection;../../../../motor/trajectory;../../../api;../../bsp;../../../../services/parameters;../../../../services/telemetry;../../../../services/lifecycle;../../../../third_party/segger_rtt
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group 00_App
    ../../../../app/: board_config.c motor_axis.c motor_state_machine.c motor_execution.c motor_maintenance.c foc_task.c bsp_task.c rtt_telemetry.c yg_protocol_owner_adapter.c yg_protocol_status_adapter.c
  group 10_Motor
    ../../../../motor/foc/: cogging_compensation.c foc_algorithm.c foc_pid.c foc_sensing.c foc_sensorless.c foc_sensorless_run.c foc_speed.c
    ../../../../motor/position/: angle_feedback.c position_cascade.c
    ../../../../motor/trajectory/: position_smooth_trajectory.c
    ../../../../motor/identification/: cogging_calibration.c cogging_map.c encoder_calibration_task.c foc_cogging_calibration.c friction_identification.c friction_identification_task.c phase_resistance.c phase_resistance_task.c
    ../../../../motor/protection/: foc_errhandle.c
  group 20_Services
    ../../../../services/lifecycle/: app_lifecycle.c motor_stop_service.c
    ../../../../services/parameters/: foc_param.c motor_axis_profile.c parameter_value_service.c
    ../../../../services/telemetry/: motor_status.c
  group 30_Communication
    ../../../../communication/can/: yg_protocol_canfd.c yg_protocol_canfd_irq.c yg_protocol_endpoint.c yg_protocol_link.c yg_protocol_runtime.c
    ../../../../communication/protocol/: yg_protocol_boot.c yg_protocol_job.c yg_protocol_message_registry.c yg_protocol_motor.c yg_protocol_motor_adapter.c yg_protocol_motor_status.c yg_protocol_parameter.c yg_protocol_readonly.c yg_protocol_readonly_payload.c yg_protocol_router.c yg_protocol_transfer.c
  group 40_Platform
    ../../ports/board/: board_startup_stm32g4.c indicator_stm32g4.c param_store_stm32g4.c
    ../../ports/boot/: boot_hw_unavailable.c
    ../../ports/comm/: comm_control_stm32g4.c comm_status_stm32g4.c
    ../../ports/motor/: encoder_spi_stm32g4.c encoder_tle5012b.c motor_pwm_stm32g4.c motor_sensing_stm32g4.c power_stage_stm32g4.c
    ../../ports/time/: time_stm32g4.c
    ../../bsp/: critical.c delay.c flash.c led.c rgb.c
    ../Core/Src/: adc.c dma.c fdcan.c gpio.c main.c spi.c stm32g4xx_hal_msp.c stm32g4xx_it.c tim.c
    ./: startup_stm32g431xx.s
  group 50_Shared
    ../../../../../shared/protocol/: yg_protocol_can_id.c yg_protocol_crc.c yg_protocol_fragment.c yg_protocol_frame_codec.c
  group 60_Common
    ../../../../common/: crc32.c heap.c utils.c
  group 90_Vendor
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c
    ../Core/Src/: system_stm32g4xx.c
    ../../../../third_party/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
