# Keil uVision project ESC-APP-AT32F456-Commissioning.uvprojx, settings and files
target ESC-APP-AT32F456-Commissioning (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456CCU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x1B000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: ESC-APP-AT32F456-Commissioning +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F456CCU7,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1 --preinclude ..\..\..\firmware\app\config\targets\r40_app_commissioning.h
  c include: .;..\..\..\firmware\third_party\segger_rtt;..\..\..\firmware\platform\bsp\mcu\at32f456;..\..\..\firmware\platform\bsp\include;..\..\..\firmware\app\composition;..\..\..\firmware\app\runtime;..\..\..\firmware\app\motor_state_machine;..\..\..\firmware\motor\math;..\..\..\firmware\communication\can;..\..\..\firmware\communication\commands;..\..\..\shared\checksum;..\..\..\shared\protocol;..\..\..\shared\boot;..\..\..\shared\image;..\..\..\shared\targets;..\..\..\firmware\motor;..\..\..\firmware\motor\foc;..\..\..\firmware\motor\calibration;..\..\..\firmware\motor\feedback;..\..\..\firmware\motor\position;..\..\..\firmware\motor\protection;..\..\..\firmware\parameters;..\..\..\firmware\app\interfaces;..\..\..\firmware\platform\sdk\at32f45x\drivers\inc;..\..\..\firmware\platform\sdk\at32f45x\cmsis\core;..\..\..\firmware\platform\sdk\at32f45x\cmsis\device;..\..\..\firmware\platform\config;..\..\..\firmware\platform\bsp;..\..\..\firmware\communication\telemetry;..\..\..\firmware\app\config;..\..\..\firmware\app\config\targets;..\..\..\firmware\platform\devices
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1b000
  scatter file: r40_app_commissioning.sct
  group 00_App
    ../../../firmware/app/composition/: app_startup.c app_tasks.c yg_protocol_owner_adapter.c yg_protocol_status_adapter.c
    ../../../firmware/app/runtime/: motor_axis.c motor_parameter_transaction.c motor_command.c motor_maintenance.c maintenance_workspace.c
    ../../../firmware/app/motor_state_machine/: motor_state_machine.c motor_state_rules.c
    ../../../firmware/app/interfaces/: motor_stop_request.c motor_status_mailbox.c
  group 10_Motor
    ../../../firmware/motor/foc/: motor_control.c speed_feedforward.c foc_algorithm.c foc_pid.c foc_sensing.c flux_observer.c sensorless_startup.c speed_control.c
    ../../../firmware/motor/protection/: motor_thermal_control.c motor_thermal.c motor_thermal_config.c motor_fault.c
    ../../../firmware/motor/feedback/: angle_feedback.c
    ../../../firmware/motor/position/: position_cascade.c
    ../../../firmware/motor/calibration/: encoder_calibration_task.c encoder_calibration_core.c
    ../../../firmware/motor/math/: control_math.c
  group 20_Parameters
    ../../../firmware/parameters/: parameter_record.c motor_axis_profile.c parameter_values.c
  group 30_Communication
    ../../../firmware/communication/can/: yg_protocol_canfd.c yg_protocol_endpoint.c yg_protocol_link.c
    ../../../firmware/communication/commands/: yg_protocol_boot.c yg_protocol_job.c yg_protocol_motor.c yg_protocol_motor_adapter.c yg_protocol_parameter.c yg_protocol_readonly.c
    ../../../firmware/communication/telemetry/: app_telemetry.c
  group 40_Platform
    ../../../firmware/app/runtime/: pwm_power_window.c bus_current_feedback.c
    ./: main.c startup_at32f456_app.s
    ../../../firmware/platform/bsp/mcu/at32f456/: system.c pwm.c adc.c encoder_spi.c can.c flash.c temperature.c led.c boot.c
    ../../../firmware/platform/devices/: encoder_mt6835.c encoder_tle5012b.c
    ../../../firmware/platform/bsp/: can_frame_codec.c bsp_adc.c bsp_led.c bsp_uart.c bsp_pwm.c bsp_encoder.c bsp_can.c
  group 50_Shared
    ../../../shared/protocol/: yg_protocol_can_id.c yg_protocol_crc.c yg_protocol_fragment.c yg_protocol_frame_codec.c
    ../../../shared/checksum/: crc32.c
    ../../../shared/boot/: device_identity.c
  group 90_Vendor
    ../../../firmware/third_party/segger_rtt/: SEGGER_RTT.c
    ../../../firmware/platform/sdk/at32f45x/cmsis/device/: system_at32f45x.c
    ../../../firmware/platform/sdk/at32f45x/drivers/src/: at32f45x_crm.c at32f45x_gpio.c at32f45x_tmr.c at32f45x_flash.c at32f45x_pwc.c at32f45x_misc.c at32f45x_adc.c at32f45x_dma.c at32f45x_can.c at32f45x_spi.c
