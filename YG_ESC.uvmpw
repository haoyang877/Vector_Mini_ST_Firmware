<?xml version='1.0' encoding='utf8'?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>YG_ESC</WorkspaceName>
  <project>
    <PathAndName>.\projects\stm32g4\MDK-ARM\ESC-APP-STM32G431.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>
  <project>
    <PathAndName>.\projects\at32f456\application\ESC-APP-AT32F456.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>
  <project>
    <PathAndName>.\projects\at32f456\application\ESC-APP-AT32F456-Commissioning.uvprojx</PathAndName>
  </project>
</ProjectWorkspace>