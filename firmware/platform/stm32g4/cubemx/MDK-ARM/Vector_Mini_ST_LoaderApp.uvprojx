# Keil uVision project Vector_Mini_ST_LoaderApp.uvprojx, settings and files
target Vector_Mini_ST_LoaderApp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FDF) IROM(0x8008800-0x801BFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Vector_Mini_ST_LoaderApp +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,CURRENT_SENSE_SHUNT_MILLIOHM=6U,YG_APP_LOADER_IMAGE=1,YG_APP_IMAGE_VERSION=0U,YG_APP_IMAGE_ROLE=1U
  c misc: --diag_suppress=1
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../../app;../../../../common;../../../../communication/can;../../../../communication/protocol;../../../../../shared/protocol;../../../../../shared/boot;../../../../../shared/image;../../../../../shared/targets;../../../../motor;../../../../motor/foc;../../../../motor/identification;../../../../motor/position;../../../../motor/protection;../../../../motor/trajectory;../../../api;../../bsp;../../../../services/parameters;../../../../services/telemetry;../../../../services/lifecycle;../../../../services/boot_handoff;../../../../third_party/segger_rtt
  memory RVCT4: ROM 0x8008800 size 0x13800
  memory RVCT9: RAM 0x20000000 size 0x7fe0
  scatter file: ..\..\..\..\..\loader\targets\vector_mini_st_g431\app.sct
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group STM32G4 board
    ../../bsp/: delay.c led.c critical.c rgb.c flash.c hw_conf.h
    ../../../../motor/position/: angle_feedback.c
    ../../../../app/: bsp_task.c
  group Motor and application
    ../../../../motor/foc/: foc_algorithm.c foc_sensing.c foc_sensorless.c foc_sensorless_run.c foc_speed.c cogging_compensation.c foc_pid.c
    ../../../../motor/identification/: phase_resistance.c foc_phase_resistance.c friction_identification.c cogging_calibration.c cogging_map.c foc_cogging_calibration.c foc_encoder_calibration.c foc_friction_identification.c
    ../../../../motor/protection/: foc_errhandle.c
    ../../../../services/parameters/: motor_axis_profile.c foc_param.c parameter_value_service.c
    ../../../../app/: motor_execution.c foc_task.c motor_state.c yg_protocol_owner_adapter.c motor_maintenance.c motor_state_machine.c
    ../../../../motor/position/: position_cascade.c
    ../../../../motor/trajectory/: position_smooth_trajectory.c
  group Communication and telemetry
    ../../../../services/telemetry/: motor_status.c
    ../../../../services/lifecycle/: app_lifecycle.c motor_stop_service.c
    ../../../../app/: rtt_telemetry.c yg_protocol_status_adapter.c
    ../../../../communication/can/: yg_protocol_runtime.c yg_protocol_canfd_irq.c
    ../../../../communication/protocol/: yg_protocol_motor_adapter.c
  group Application support
    ../../../../common/: heap.c crc32.c utils.c
    ../../../../app/: board_config.c
    ../../../../motor/: data_type.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group SEGGER RTT
    ../../../../third_party/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group STM32G4 ports
    ../../ports/comm/: comm_status_stm32g4.c comm_control_stm32g4.c
    ../../ports/time/: time_stm32g4.c
    ../../ports/motor/: motor_pwm_stm32g4.c power_stage_stm32g4.c motor_sensing_stm32g4.c encoder_spi_stm32g4.c encoder_tle5012b.c
    ../../ports/board/: board_startup_stm32g4.c indicator_stm32g4.c param_store_stm32g4.c
    ../../ports/boot/: boot_hw_stm32g4.c
  group Shared Protocol
    ../../../../../shared/protocol/: yg_protocol_crc.c yg_protocol_frame_codec.c yg_protocol_can_id.c yg_protocol_fragment.c
  group Communication YG Protocol
    ../../../../communication/can/: yg_protocol_link.c yg_protocol_canfd.c yg_protocol_endpoint.c
    ../../../../communication/protocol/: yg_protocol_message_registry.c yg_protocol_router.c yg_protocol_motor.c yg_protocol_motor_status.c yg_protocol_readonly.c yg_protocol_readonly_payload.c yg_protocol_job.c yg_protocol_boot.c yg_protocol_parameter.c yg_protocol_transfer.c
  group APP Boot Handoff
    ../../../../services/boot_handoff/: boot_handoff.c
    ../../../../../shared/boot/: image_mailbox.c
    ../../../../../shared/image/: image_transfer.c nv_record.c nv_sha256.c
    ../../../../../shared/targets/: vector_mini_st_g431_app_descriptor.c
