# Keil uVision project ESC-LOADER-AT32F456.uvprojx, settings and files
target ESC-LOADER-AT32F456 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456CCU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.2
  cpu: IRAM(0x20000000-0x20016FDF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ESC-LOADER-AT32F456 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F456CCU7,USE_STDPERIPH_DRIVER
  c include: ..\..\..\shared\targets\yg_esc_v1_at32f456;.;..\..\core;..\..\product;..\..\ports\include;..\..\ports\at32f456;..\..\boards\yg_esc_v1;..\..\..\shared\targets;..\..\..\shared\image;..\..\..\shared\boot;..\..\..\shared\checksum;..\..\..\shared\protocol;..\..\..\firmware\platform\sdk\at32f45x\cmsis\core;..\..\..\firmware\platform\sdk\at32f45x\cmsis\device;..\..\..\firmware\platform\sdk\at32f45x\drivers\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x16fe0
  scatter file: loader.sct
  group Loader core
    ../../core/: upgrade.c
  group Loader runtime
    ../../runtime/: main.c
  group Shared contracts
    ../../../shared/checksum/: crc32.c
    ../../../shared/boot/: image_mailbox.c device_identity.c
    ../../../shared/protocol/: yg_protocol_can_id.c yg_protocol_crc.c yg_protocol_fragment.c yg_protocol_frame_codec.c yg_protocol_upgrade_wire.c
  group Shared image
    ../../../shared/image/: image_transfer.c
  group Loader product
    ../../product/: parameters.c
  group AT32 port
    ../../ports/at32f456/: platform.c can_port.c
    ../../boards/yg_esc_v1/: board.c
  group AT32 support
    ../../../projects/at32f456/application/: startup_at32f456_app.s
    ../../../firmware/platform/sdk/at32f45x/cmsis/device/: system_at32f45x.c
    ../../../firmware/platform/sdk/at32f45x/drivers/src/: at32f45x_crm.c at32f45x_flash.c at32f45x_gpio.c at32f45x_pwc.c at32f45x_tmr.c at32f45x_can.c
