# Keil uVision project R40_F456_App_Off.uvprojx, settings and files
target R40_F456_App_Off (6220000::V6.22::ARMCLANG)
  device: AT32F456CCU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x1B000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: R40_F456_App_Off +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F456CCU7,USE_STDPERIPH_DRIVER,APP_TARGET_R40_F456=1,FOC_ACTIVE_HW_PROFILE=2,FOC_ACTIVE_MOTOR_PROFILE=2,R40_APP_PHASE_LOCK=1,R40_APP_BINDINGS=1,R40_TEMPERATURE_SENSING_ENABLED=1,R40_APP_MCU_TEMPERATURE_OPTIONAL=1
  c include: .;..\..\..\third_party\segger_rtt;..\bsp;..\ports;..\..\api;..\..\..\app\composition;..\..\..\app\runtime;..\..\..\app\motor_state_machine;..\..\..\motor\math;..\..\..\communication\can;..\..\..\communication\protocol;..\..\..\..\shared\checksum;..\..\..\..\shared\protocol;..\..\..\..\shared\boot;..\..\..\..\shared\image;..\..\..\..\shared\targets;..\..\..\motor;..\..\..\motor\foc;..\..\..\motor\calibration;..\..\..\motor\feedback;..\..\..\motor\position;..\..\..\motor\protection;..\..\..\parameters;..\..\..\app\interfaces;..\..\..\third_party\at32f45x\drivers\inc;..\..\..\third_party\at32f45x\cmsis\core;..\..\..\third_party\at32f45x\cmsis\device
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1b000
  scatter file: .\r40_app.sct
  group Shared APP and motor
    ../../../app/composition/: app_startup.c app_tasks.c yg_protocol_owner_adapter.c yg_protocol_status_adapter.c
    ../../../app/runtime/: motor_axis.c motor_parameter_transaction.c motor_command.c motor_maintenance.c maintenance_workspace.c
    ./: app_telemetry.c
    ../../../third_party/segger_rtt/: SEGGER_RTT.c
    ../../../app/motor_state_machine/: motor_state_machine.c motor_state_rules.c
    ../../../app/interfaces/: motor_stop_request.c motor_status_mailbox.c
    ../../../motor/foc/: motor_control.c speed_feedforward.c foc_algorithm.c foc_pid.c foc_sensing.c flux_observer.c sensorless_startup.c speed_control.c
    ../../../motor/protection/: motor_thermal_control.c motor_thermal.c motor_thermal_config.c motor_fault.c
    ../../../motor/feedback/: angle_feedback.c
    ../../../motor/position/: position_cascade.c
    ../../../motor/calibration/: encoder_calibration_task.c encoder_calibration_core.c
    ../../../motor/math/: control_math.c
    ../../../parameters/: parameter_record.c motor_axis_profile.c parameter_values.c
    ../../../communication/can/: yg_protocol_canfd.c yg_protocol_canfd_irq.c yg_protocol_endpoint.c yg_protocol_link.c yg_protocol_runtime.c yg_protocol_frame_queue.c
    ../../../communication/protocol/: yg_protocol_boot.c yg_protocol_job.c yg_protocol_message_registry.c yg_protocol_motor.c yg_protocol_motor_adapter.c yg_protocol_motor_status.c yg_protocol_parameter.c yg_protocol_readonly.c yg_protocol_readonly_payload.c yg_protocol_router.c
    ../../../../shared/protocol/: yg_protocol_can_id.c yg_protocol_crc.c yg_protocol_fragment.c yg_protocol_frame_codec.c
    ../../../../shared/checksum/: crc32.c
    ../../../../shared/boot/: device_identity.c
  group AT32 application
    ./: main.c bus_current_feedback.c
  group AT32 platform
    ../bsp/: r40_clock.c r40_platform.c
    ../ports/: time_at32f456.c power_stage_at32f456.c motor_pwm_at32f456.c motor_sensing_at32f456.c encoder_mt6835.c comm_at32f456.c param_store_at32f456.c temperature_at32f456.c motor_temperature_at32f456.c board_at32f456.c indicator_at32f456.c boot_at32f456.c
  group Vendor CMSIS
    ../../../third_party/at32f45x/cmsis/device/: system_at32f45x.c
    ./: startup_at32f456_app.s
  group Vendor Drivers
    ../../../third_party/at32f45x/drivers/src/: at32f45x_crm.c at32f45x_gpio.c at32f45x_tmr.c at32f45x_flash.c at32f45x_pwc.c at32f45x_misc.c at32f45x_adc.c at32f45x_dma.c at32f45x_can.c at32f45x_spi.c
