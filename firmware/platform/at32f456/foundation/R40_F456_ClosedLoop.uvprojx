# Keil uVision project R40_F456_ClosedLoop.uvprojx, settings and files
target R40_F456_ClosedLoop (6220000::V6.22::ARMCLANG)
  device: AT32F456CCU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x1B000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: R40_F456_ClosedLoop +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F456CCU7,USE_STDPERIPH_DRIVER,R40_OPENLOOP_POWER_ENABLED=1,R40_OUTPUT_SINCOS_DIAGNOSTICS=1,R40_OPENLOOP_SINCOS_TEST=1,R40_OL_VOLTAGE_V=1.0f,R40_OL_DURATION_MS=10000U,R40_OL_CURRENT_LIMIT_A=3.0f,R40_CLOSEDLOOP_TEST=1
  c include: ..\bsp;..\..\api;..\..\..\third_party\at32f45x\drivers\inc;..\..\..\third_party\at32f45x\cmsis\core;..\..\..\third_party\at32f45x\cmsis\device;..\..\..\motor;..\..\..\motor\math;..\..\..\motor\foc;..\..\..\motor\protection;..\..\..\motor\feedback;..\..\..\motor\calibration
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1b000
  scatter file: .\r40_closedloop.sct
  group Foundation
    ./: openloop_main.c openloop_model.c closedloop_bench.c
    ../../../motor/math/: control_math.c
    ../../../motor/foc/: foc_algorithm.c foc_pid.c speed_control.c speed_feedforward.c foc_sensing.c
    ../../../motor/protection/: motor_thermal.c motor_fault.c
    ../../../motor/feedback/: angle_feedback.c
    ../../../motor/calibration/: encoder_calibration_core.c
  group Platform
    ../bsp/: r40_clock.c r40_platform.c
    ../ports/: time_at32f456.c power_stage_at32f456.c motor_sensing_at32f456.c comm_at32f456.c encoder_mt6835.c motor_pwm_at32f456.c temperature_at32f456.c motor_temperature_at32f456.c param_store_at32f456.c
  group Vendor CMSIS
    ../../../third_party/at32f45x/cmsis/device/: system_at32f45x.c
    ../../../third_party/at32f45x/cmsis/: startup_at32f45x.s
  group Vendor Drivers
    ../../../third_party/at32f45x/drivers/src/: at32f45x_crm.c at32f45x_gpio.c at32f45x_tmr.c at32f45x_flash.c at32f45x_pwc.c at32f45x_misc.c at32f45x_adc.c at32f45x_dma.c at32f45x_can.c at32f45x_spi.c
