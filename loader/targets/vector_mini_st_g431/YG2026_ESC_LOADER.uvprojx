# Keil uVision project YG2026_ESC_LOADER.uvprojx, settings and files
target YG2026_ESC_LOADER (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FDF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: YG2026_ESC_LOADER +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ..\..\..\shared\targets\vector_mini_st_g431;.;..\..\core;..\..\product;..\..\ports\include;..\..\ports\stm32g4;..\..\boards\vector_mini_st;..\..\..\shared\targets;..\..\..\shared\image;..\..\..\shared\boot;..\..\..\shared\checksum;..\..\..\shared\protocol;..\..\..\firmware\platform\sdk\stm32g4\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\..\firmware\platform\sdk\stm32g4\Drivers\CMSIS\Include;..\..\..\firmware\platform\sdk\stm32g4\Drivers\CMSIS\Device\ST\STM32G4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x7fe0
  scatter file: loader.sct
  group Loader core
    ../../core/: upgrade.c
  group Loader runtime
    ../../runtime/: main.c
  group G431 port
    ../../ports/stm32g4/: can_port.c flash_guard.c platform.c
    ../../boards/vector_mini_st/: board.c
  group Shared contracts
    ../../../shared/checksum/: crc32.c
    ../../../shared/boot/: image_mailbox.c device_identity.c
    ../../../shared/protocol/: yg_protocol_can_id.c yg_protocol_crc.c yg_protocol_fragment.c yg_protocol_frame_codec.c yg_protocol_upgrade_wire.c
  group ST support
    ../../../projects/stm32g4/MDK-ARM/: startup_stm32g431xx.s
    ../../../firmware/platform/bsp/mcu/stm32g4/generated/Core/Src/: system_stm32g4xx.c
    ../../../firmware/platform/sdk/stm32g4/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c
  group Shared image
    ../../../shared/image/: image_transfer.c
  group Loader product
    ../../product/: parameters.c
