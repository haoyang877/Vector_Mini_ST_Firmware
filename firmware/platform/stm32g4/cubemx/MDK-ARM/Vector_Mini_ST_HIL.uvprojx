# Keil uVision project Vector_Mini_ST_HIL.uvprojx, settings and files
target Vector_Mini_ST_HIL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000020-0x20007FFF) IROM(0x8004000-0x801BFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Vector_Mini_ST +hex
  AfterMake: "..\..\..\..\..\.venv\Scripts\python.exe" "..\..\..\..\..\tools\build\keil_app_record.py" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,APP_LOADER_LAYOUT=1,SERVO_HIL_ENABLE=1
  c misc: --diag_suppress=1
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../../../app;../../../../common;../../../../communication/can;../../../../communication/protocol;../../../../motor;../../../../motor/foc;../../../../motor/identification;../../../../motor/position;../../../../motor/protection;../../../../motor/trajectory;../../../api;../../bsp;../../../../services/parameters;../../../../services/telemetry;../../../../third_party/segger_rtt;../../../../../tests/hil/firmware;..\..\..\..\..\shared;..\..\..\..\services\boot_handoff
  memory RVCT4: ROM 0x08004000 size 0x18000
  memory RVCT9: RAM 0x20000020 size 0x7FE0
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: Vector_Mini_ST.sct
  link misc: --pad=0xFF --keep=keil_boot_record.o(BOOT_RECORD)
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group STM32G4 board
    ../../bsp/: delay.c led.c encoder.c rgb.c flash.c hw_conf.h
    ../../../../app/: bsp_task.c
  group Motor and application
    ../../../../motor/foc/: foc_algorithm.c foc_sensing.c foc_sensorless.c foc_pid.c
    ../../../../motor/identification/: foc_calibration.c phase_resistance.c foc_phase_resistance.c friction_identification.c foc_friction_identification.c
    ../../../../motor/protection/: motor_thermal.c foc_errhandle.c
    ../../../../services/parameters/: motor_axis_profile.c foc_param.c
    ../../../../motor/: motor_load_profile.c speed_feedforward.c
    ../../../../app/: foc_run.c motor_thermal_control.c foc_task.c
    ../../../../motor/position/: position_impedance.c position_cascade.c
    ../../../../motor/trajectory/: position_smooth_trajectory.c foc_traptraj.c
  group Communication and telemetry
    ../../../../services/telemetry/: motor_status.c
    ../../../../communication/protocol/: can_motor_status.c
    ../../ports/comm/: comm_status_stm32g4.c
    ../../ports/time/: time_stm32g4.c
    ../../../../communication/can/: interface_can.c
  group Application support
    ../../../../../tests/hil/firmware/: servo_hil.c
    ../../../../app/: board_config.c parameter_persistence.c common_inc.h
    ../../../../common/: utils.c
    ../../../../motor/: data_type.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group SEGGER RTT
    ../../../../third_party/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group STM32G4 ports
    ../../ports/motor/: motor_outer_stm32g4.c motor_current_stm32g4.c
  group Boot handoff
    ../../../../../shared/: boot_contract.c
    ../../../../services/boot_handoff/: boot_handoff.c
    ../../../../app/: boot_handoff_app.c
    ../../ports/boot/: boot_stm32g4.c keil_boot_record.c
