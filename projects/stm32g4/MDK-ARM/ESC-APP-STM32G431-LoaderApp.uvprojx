# Keil uVision project ESC-APP-STM32G431-LoaderApp.uvprojx, settings and files
target ESC-APP-STM32G431-LoaderApp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FDF) IROM(0x8004000-0x801BFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ESC-APP-STM32G431-LoaderApp +hex
  AfterMake: "..\..\..\.venv\Scripts\python.exe" "..\..\..\tools\build\keil_loader_app.py" "#L" --target vector_mini_st_g431
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,CURRENT_SENSE_SHUNT_MILLIOHM=6U,BSP_BOARD=1U,YG_APP_LOADER_IMAGE=1,YG_APP_IMAGE_VERSION=TARGET_APP_VERSION,YG_APP_IMAGE_ROLE=1U
  c misc: --diag_suppress=1 -DFIRMWARE_TARGET_STM32_APP --preinclude ..\..\..\firmware\config\board_config.h
  c include: ..\..\..\shared\targets\vector_mini_st_g431;..\..\..\firmware\platform\bsp\mcu\stm32g4\generated\Core\Inc;..\..\..\firmware\platform\sdk\stm32g4\Drivers\STM32G4xx_HAL_Driver\Inc;..\..\..\firmware\platform\sdk\stm32g4\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\..\..\firmware\platform\sdk\stm32g4\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\..\..\firmware\platform\sdk\stm32g4\Drivers\CMSIS\Include;..\..\..\firmware\app;..\..\..\firmware\motor\math;..\..\..\firmware\communication;..\..\..\shared\checksum;..\..\..\shared\protocol;..\..\..\shared\boot;..\..\..\shared\image;..\..\..\shared\targets;..\..\..\firmware\motor;..\..\..\firmware\motor\control;..\..\..\firmware\config;..\..\..\firmware\motor\sensing;..\..\..\firmware\motor\calibration;..\..\..\firmware\motor\feedback;..\..\..\firmware\motor\protection;..\..\..\firmware\platform\bsp\include;..\..\..\firmware\platform\bsp\mcu\stm32g4;..\..\..\firmware\parameters;..\..\..\firmware\platform\bsp
  memory RVCT4: ROM 0x8004000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x7fe0
  scatter file: ..\..\..\loader\targets\vector_mini_st_g431\app.sct
  group 00_App
    ../../../firmware/app/: app.c motor_axis.c motor_calibration.c motor_state_machine.c app_protocol.c app_motor_configuration.c app_loader.c
  group 10_Motor
    ../../../firmware/motor/control/: motor_control.c speed_feedforward.c foc.c foc_output.c pi_controller.c sensorless_startup.c speed_control.c position_control.c position_otg.c
    ../../../firmware/motor/protection/: motor_thermal_control.c motor_thermal.c motor_thermal_config.c motor_fault.c
    ../../../firmware/motor/sensing/: motor_current.c motor_voltage.c mcu_temperature_sensing.c
    ../../../firmware/motor/feedback/: flux_observer.c encoder_feedback.c output_encoder.c linear_hall.c
    ../../../firmware/motor/calibration/: encoder_calibration.c phase_resistance.c
    ../../../firmware/motor/math/: control_math.c
  group 20_Parameters
    ../../../firmware/parameters/: parameter_record.c motor_axis_profile.c parameter_values.c
  group 30_Communication
    ../../../firmware/communication/: yg_protocol.c yg_protocol_boot.c
  group 40_Platform
    ../../../firmware/platform/bsp/mcu/stm32g4/: boot_hw_stm32g4.c can.c encoder_spi.c pwm.c adc.c flash.c system.c
    ../../../firmware/platform/bsp/mcu/stm32g4/generated/Core/Src/: adc.c fdcan.c gpio.c spi.c stm32g4xx_hal_msp.c stm32g4xx_it.c tim.c
    ../application/: main.c
    ./: startup_stm32g431xx.s
  group 50_Shared
    ../../../shared/protocol/: yg_protocol_can_id.c yg_protocol_crc.c yg_protocol_frame_codec.c
    ../../../shared/checksum/: crc32.c
    ../../../shared/boot/: device_identity.c image_mailbox.c
    ../../../shared/targets/: vector_mini_st_g431_app_descriptor.c
  group 90_Vendor
    ../../../firmware/platform/sdk/stm32g4/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c
    ../../../firmware/platform/bsp/mcu/stm32g4/generated/Core/Src/: system_stm32g4xx.c
