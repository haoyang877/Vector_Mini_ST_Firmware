# Keil uVision project Vector_Mini_ST.uvprojx, settings and files
target Vector_Mini_ST (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801BFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Vector_Mini_ST +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx,ACTIVE_MECHANICAL_LOAD_PROFILE=MECHANICAL_LOAD_PROFILE_DAMPING_RING_1P5NM
  c misc: --diag_suppress=1
  c include: ../Core/Inc;../USB_Device/App;../USB_Device/Target;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;D:/Keil5/ARM/CMSIS/5.4.0/CMSIS/Include;../Firmware;../Firmware/Composition;../Firmware/Runtime/MotorControl;../Firmware/Runtime/Supervisor;../Firmware/Communication;../Firmware/Communication/Protocol;../Firmware/Communication/Router;../Firmware/Communication/Transport;../Firmware/Application;../Firmware/Application/Indicators;../Firmware/Core/Services/Math;../Firmware/Core/Services/Modulation;../Firmware/Core/Services/RotorFeedback;../Firmware/Core/Services/Identification;../Firmware/Core/Services/CurrentControl;../Firmware/Core/Services/MotionControl;../Firmware/Core/Services/Measurement;../Firmware/Ports;../Firmware/Platform/Stm32G431;../Firmware/Product;../Firmware/Core/Config;../Firmware/Bsp/Api;../Firmware/Bsp/Boards;../Firmware/Bsp/Boards/VectorMiniSt;../Firmware/Drivers/Angle/Tle5012b;../Bootloader;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/Third_Party/SEGGER/RTT
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Firmware/Application/Indicators
    ../Firmware/Application/Indicators/: led.c rgb.c
  group Firmware/Application
    ../Firmware/Application/: application_endpoints.c power_stage.c parameter_service.c diagnostic_service.c update_service.c can_configuration_service.c calibration_service.c identification_service.c
  group Firmware/Core/Application
    ../Firmware/Core/Application/: communication_watchdog_service.c control_authority_service.c device_lifecycle.c friction_identification_service.c motor_command_service.c motor_commissioning_workflow.c parameter_transaction_service.c rotor_calibration_service.c
  group Firmware/Core/Services/Safety
    ../Firmware/Core/Services/Safety/: fault_manager.c
  group Firmware/Core/Infrastructure/Telemetry
    ../Firmware/Core/Infrastructure/Telemetry/: telemetry_service.c
  group Firmware/Core/Communication/Can
    ../Firmware/Core/Communication/Can/: can_response_service.c
  group Firmware/Platform/Stm32G431
    ../Firmware/Platform/Stm32G431/: power_stage_tim1.c measurement_adc12.c board_runtime.c monotonic_clock_stm32g431.c diagnostic_rtt_stm32g431.c execution_timer_stm32g431.c reset_reason_stm32g431.c device_identity_stm32g431.c angle_serial_stm32g431.c angle_serial_stm32g431_config.c parameter_store_flash.c can_fdcan1_transport.c usb_cdc_transport.c indicator_stm32g431.c
  group Firmware/Product
    ../Firmware/Product/: control_loop_config.h product_manifest.c motor_profiles.c mechanical_load_profiles.c encoder_profiles.c control_tuning_profile.c
  group Firmware/Core/Communication/Formatting
    ../Firmware/Core/Communication/Formatting/: text_writer.c
  group Firmware/Core/Config
    ../Firmware/Core/Config/: product_catalog.c
  group Firmware/Core/Infrastructure/Parameters
    ../Firmware/Core/Infrastructure/Parameters/: parameter_manager.c
  group Firmware/Bsp/Boards
    ../Firmware/Bsp/Boards/: bsp_board.c bsp_board.h
  group Firmware/Bsp/Boards/VectorMiniSt
    ../Firmware/Bsp/Boards/VectorMiniSt/: vector_mini_st_bsp.c vector_mini_st_bsp_identity.c vector_mini_st_angle_serial.c vector_mini_st_storage.c
  group Firmware/Core/Services/Modulation
    ../Firmware/Core/Services/Modulation/: svpwm.c
  group Firmware/Core/Services/Math
    ../Firmware/Core/Services/Math/: fast_math.c
  group Firmware/Core/Services/RotorFeedback
    ../Firmware/Core/Services/RotorFeedback/: encoder.c
  group Firmware/Core/Services/Measurement
    ../Firmware/Core/Services/Measurement/: measurement_model.c
  group Firmware/Core/Services/Identification
    ../Firmware/Core/Services/Identification/: phase_resistance.c friction_identification.c
  group Firmware/Core/Services/CurrentControl
    ../Firmware/Core/Services/CurrentControl/: pi_controller.c current_control_math.c
  group Firmware/Core/Services/MotionControl
    ../Firmware/Core/Services/MotionControl/: position_impedance.c position_cascade.c trapezoidal_trajectory.c
  group Firmware/Runtime/MotorControl
    ../Firmware/Runtime/MotorControl/: motor_control_types.h current_control_runtime.c measurement_runtime.c sensorless_runtime.c encoder_calibration_runtime.c encoder_direction_calibration_runtime.c cogging_identification_runtime.c current_offset_calibration_runtime.c electrical_zero_calibration_runtime.c phase_resistance_runtime.c friction_identification_runtime.c motor_state_runtime.c parameter_snapshot.c parameter_persistence_adapter.c parameter_transaction_adapter.c control_mode_runtime.c motor_control_runtime.c rotor_calibration_port_adapter.c motor_service_adapter.c fault_port_adapter.c
  group Firmware/Runtime/Supervisor
    ../Firmware/Runtime/Supervisor/: supervisor_task.c
  group Firmware/Communication/Transport
    ../Firmware/Communication/Transport/: byte_ring_buffer.c
  group Firmware/Communication/Protocol
    ../Firmware/Communication/Protocol/: can_protocol_v1.c usb_protocol_v1.c
  group Firmware/Communication/Router
    ../Firmware/Communication/Router/: can_command_router.c usb_command_router.c
  group Firmware/Communication/Interfaces
    ../Firmware/Communication/: interface_can.c interface_usb.c
  group Firmware/Composition
    ../Firmware/Composition/: firmware_composition.c tle5012b_rotor_sensor_adapter.c product_config_bridge.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/SEGGER RTT
    ../Middlewares/Third_Party/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
