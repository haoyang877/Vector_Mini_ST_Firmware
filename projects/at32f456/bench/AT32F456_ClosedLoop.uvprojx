# Keil uVision project AT32F456_ClosedLoop.uvprojx, settings and files
target AT32F456_ClosedLoop (6220000::V6.22::ARMCLANG)
  device: AT32F456CCU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x1B000) IROM(0x08000000,0x1C000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: AT32F456_ClosedLoop +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F456CCU7,USE_STDPERIPH_DRIVER,AT32_OPENLOOP_POWER_ENABLED=1,AT32_OL_VOLTAGE_V=1.0f,AT32_OL_DURATION_MS=10000U,AT32_OL_CURRENT_LIMIT_A=3.0f,AT32_CLOSEDLOOP_TEST=1,BSP_BOARD=2U
  c misc: -DFIRMWARE_TARGET_AT32_BENCH
  c include: ..\..\..\firmware\platform\bsp\mcu\at32f456;..\..\..\firmware\platform\bsp\include;..\..\..\firmware\platform\sdk\at32f45x\drivers\inc;..\..\..\firmware\platform\sdk\at32f45x\cmsis\core;..\..\..\firmware\platform\sdk\at32f45x\cmsis\device;..\..\..\firmware\motor;..\..\..\firmware\motor\math;..\..\..\firmware\motor\control;..\..\..\firmware\config;..\..\..\firmware\motor\sensing;..\..\..\firmware\motor\protection;..\..\..\firmware\motor\feedback;..\..\..\firmware\motor\calibration;..\..\..\firmware\platform\bsp;..\..\..\shared\targets;..\..\..\shared\protocol
  memory RVCT4: ROM 0x8000000 size 0x1C000
  memory RVCT9: RAM 0x20000000 size 0x1b000
  scatter file: at32f456_closedloop.sct
  group Foundation
    ../../../tests/bench/at32f456/: openloop_main.c openloop_model.c closedloop_bench.c
    ../../../firmware/motor/math/: control_math.c
    ../../../firmware/motor/control/: foc.c foc_output.c pi_controller.c speed_control.c speed_feedforward.c
    ../../../firmware/motor/protection/: motor_thermal.c motor_fault.c
    ../../../firmware/motor/feedback/: encoder_feedback.c output_encoder.c linear_hall.c
    ../../../firmware/motor/sensing/: motor_current.c motor_voltage.c mcu_temperature_sensing.c
  group Platform
    ../../../firmware/platform/bsp/mcu/at32f456/: system.c pwm.c adc.c can.c encoder_spi.c flash.c
  group Vendor CMSIS
    ../../../firmware/platform/sdk/at32f45x/cmsis/device/: system_at32f45x.c
    ../../../firmware/platform/sdk/at32f45x/cmsis/: startup_at32f45x.s
  group Vendor Drivers
    ../../../firmware/platform/sdk/at32f45x/drivers/src/: at32f45x_crm.c at32f45x_gpio.c at32f45x_tmr.c at32f45x_flash.c at32f45x_pwc.c at32f45x_misc.c at32f45x_adc.c at32f45x_dma.c at32f45x_can.c at32f45x_spi.c
