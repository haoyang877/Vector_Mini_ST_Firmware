# Keil uVision project ESC-APP-AT32F456.uvprojx, settings and files
target ESC-APP-AT32F456 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F456CCU7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.2
  cpu: IRAM(0x20000000-0x20016FDF) IROM(0x8004000-0x801BFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ESC-APP-AT32F456 +hex
  AfterMake: "..\..\..\.venv\Scripts\python.exe" "..\..\..\tools\build\keil_loader_app.py" "#L" --target yg_esc_v1_at32f456
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F456CCU7,USE_STDPERIPH_DRIVER,BSP_BOARD=2U,AT32_KEIL_CALIBRATION=1,YG_APP_LOADER_IMAGE=1,YG_APP_IMAGE_VERSION=TARGET_APP_VERSION,YG_APP_IMAGE_ROLE=1U
  c misc: --diag_suppress=1 -DFIRMWARE_TARGET_AT32_OFF --preinclude ..\..\..\firmware\config\board_config.h
  c include: ..\..\..\shared\targets\yg_esc_v1_at32f456;.;..\..\..\firmware\third_party\segger_rtt;..\..\..\firmware\platform\bsp\mcu\at32f456;..\..\..\firmware\platform\bsp\include;..\..\..\firmware\app;..\..\..\firmware\motor\math;..\..\..\firmware\communication;..\..\..\shared\checksum;..\..\..\shared\protocol;..\..\..\shared\boot;..\..\..\shared\image;..\..\..\shared\targets;..\..\..\firmware\motor;..\..\..\firmware\motor\control;..\..\..\firmware\config;..\..\..\firmware\motor\sensing;..\..\..\firmware\motor\calibration;..\..\..\firmware\motor\feedback;..\..\..\firmware\motor\protection;..\..\..\firmware\parameters;..\..\..\firmware\platform\sdk\at32f45x\drivers\inc;..\..\..\firmware\platform\sdk\at32f45x\cmsis\core;..\..\..\firmware\platform\sdk\at32f45x\cmsis\device;..\..\..\firmware\platform\bsp
  memory RVCT4: ROM 0x8004000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x16fe0
  scatter file: ..\..\..\loader\targets\yg_esc_v1_at32f456\app.sct
  group 00_App
    ../../../firmware/app/: app.c motor_axis.c motor_calibration.c motor_state_machine.c app_protocol.c app_motor_configuration.c app_loader.c
    ../../../firmware/app/composition/: app_rtt.c
  group 10_Motor
    ../../../firmware/motor/control/: motor_control.c speed_feedforward.c foc.c foc_output.c pi_controller.c sensorless_startup.c speed_control.c position_control.c position_otg.c
    ../../../firmware/motor/protection/: motor_thermal_control.c motor_thermal.c motor_thermal_config.c motor_fault.c
    ../../../firmware/motor/sensing/: motor_current.c motor_voltage.c mcu_temperature_sensing.c
    ../../../firmware/motor/feedback/: flux_observer.c output_encoder.c linear_hall.c encoder_feedback.c
    ../../../firmware/motor/calibration/: encoder_calibration.c phase_resistance.c
    ../../../firmware/motor/math/: control_math.c
  group 20_Parameters
    ../../../firmware/parameters/: parameter_record.c motor_axis_profile.c parameter_values.c
  group 30_Communication
    ../../../firmware/communication/: yg_protocol.c yg_protocol_boot.c
  group 40_Platform
    ./: main.c hardware_check.c startup_at32f456_app.s
    ../../../firmware/platform/bsp/mcu/at32f456/: system.c pwm.c adc.c encoder_spi.c can.c flash.c boot_loader.c
  group 50_Shared
    ../../../shared/protocol/: yg_protocol_can_id.c yg_protocol_crc.c yg_protocol_frame_codec.c
    ../../../shared/checksum/: crc32.c
    ../../../shared/boot/: device_identity.c image_mailbox.c
    ../../../shared/targets/: yg_esc_v1_at32f456_app_descriptor.c
  group 90_Vendor
    ../../../firmware/platform/sdk/at32f45x/cmsis/device/: system_at32f45x.c
    ../../../firmware/platform/sdk/at32f45x/drivers/src/: at32f45x_crm.c at32f45x_gpio.c at32f45x_tmr.c at32f45x_flash.c at32f45x_pwc.c at32f45x_misc.c at32f45x_adc.c at32f45x_dma.c at32f45x_can.c at32f45x_spi.c
  group RTT
    ../../../firmware/third_party/segger_rtt/: SEGGER_RTT.c
